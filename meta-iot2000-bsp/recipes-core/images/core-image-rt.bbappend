require wic-image.inc
