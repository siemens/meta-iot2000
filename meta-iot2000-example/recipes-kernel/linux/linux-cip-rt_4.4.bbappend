FILESEXTRAPATHS_prepend := "${THISDIR}/configs:"

SRC_URI += "file://iot2000-example.scc"
