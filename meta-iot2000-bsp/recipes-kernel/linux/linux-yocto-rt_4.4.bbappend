require linux-yocto.inc

SRC_URI += " \
    file://defconfig"
