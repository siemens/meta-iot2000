inherit populate_sdk_qt5