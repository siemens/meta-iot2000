FILESEXTRAPATHS_prepend := "${THISDIR}/patches-1.6:"

require go-cross-iot2000.inc
