# Recipe created by recipetool

SUMMARY = "A visual tool for wiring the Internet of Things"
HOMEPAGE = "http://nodered.org"
# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
LICENSE = "ISC & MIT & Apache-2.0 & PD & BSD & BSD-3-Clause & BSD-2-Clause & EUPL-1.1"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d6f37569f5013072e9490d2194d10ae6 \
                    file://public/vendor/ace/LICENSE;md5=794d11c5219c59c9efa2487c2b4066b2 \
                    file://node_modules/passport-oauth2-client-password/LICENSE;md5=95ca2874231d1b4d06ca94c35aa604f7 \
                    file://node_modules/passport-oauth2-client-password/node_modules/passport-strategy/LICENSE;md5=f694b9c022a5bf0f2c3976a047fed39c \
                    file://node_modules/mustache/LICENSE;md5=33fa3c7f27611cfb1191e5aa2bb107b1 \
                    file://node_modules/passport/LICENSE;md5=7daa135d870fa6623646ce9a3f5cb6bb \
                    file://node_modules/passport/node_modules/passport-strategy/LICENSE;md5=f694b9c022a5bf0f2c3976a047fed39c \
                    file://node_modules/xml2js/LICENSE;md5=d9fc599c8d9e6f8665063862aac66dfc \
                    file://node_modules/xml2js/node_modules/xmlbuilder/LICENSE;md5=eb65a7137aed46eac98ceb8cb8b057a1 \
                    file://node_modules/xml2js/node_modules/xmlbuilder/node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/xml2js/node_modules/sax/LICENSE;md5=326d5674181c4bb210e424772c60fa80 \
                    file://node_modules/jsonata/LICENSE;md5=0a2fefbb55a84675607e8efd57183e99 \
                    file://node_modules/passport-http-bearer/LICENSE;md5=f694b9c022a5bf0f2c3976a047fed39c \
                    file://node_modules/passport-http-bearer/node_modules/passport-strategy/LICENSE;md5=f694b9c022a5bf0f2c3976a047fed39c \
                    file://node_modules/uglify-js/LICENSE;md5=4677f24cba62224b999bcb8da6e05fb4 \
                    file://node_modules/uglify-js/node_modules/source-map/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/uglify-js/node_modules/yargs/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/camelcase/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/window-size/LICENSE-MIT;md5=356865268599668702955e0728242b7e \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/decamelize/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/LICENSE.txt;md5=83623193d3051ca8068a89a455c699ca \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/right-align/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/right-align/node_modules/align-text/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/right-align/node_modules/align-text/node_modules/longest/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/right-align/node_modules/align-text/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/right-align/node_modules/align-text/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/right-align/node_modules/align-text/node_modules/repeat-string/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/center-align/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/center-align/node_modules/align-text/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/center-align/node_modules/align-text/node_modules/longest/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/center-align/node_modules/align-text/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/center-align/node_modules/align-text/node_modules/kind-of/node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/center-align/node_modules/align-text/node_modules/repeat-string/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/uglify-js/node_modules/yargs/node_modules/cliui/node_modules/center-align/node_modules/lazy-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/uglify-js/node_modules/uglify-to-browserify/LICENSE;md5=10d1d4024d61361102888126d4347f7b \
                    file://node_modules/uglify-js/node_modules/async/LICENSE;md5=64a378b2b01424fe22d54bc626175994 \
                    file://node_modules/i18next/license;md5=b352c50e7426c74d9e3ff402e516912b \
                    file://node_modules/i18next/node_modules/i18next-client/license;md5=d79f2ef6f5765f02c4b89fb58dda7352 \
                    file://node_modules/i18next/node_modules/cookies/LICENSE;md5=682d05ded140d8b9878944462f099014 \
                    file://node_modules/i18next/node_modules/cookies/node_modules/keygrip/LICENSE.txt;md5=1860af38bb0bf0190d08c9ddf3d2165f \
                    file://node_modules/i18next/node_modules/cookies/node_modules/depd/LICENSE;md5=89378960d0c54c30539e50c7a78ce846 \
                    file://node_modules/when/LICENSE.txt;md5=fc543630b85dc079e12b1e812ede0d3a \
                    file://node_modules/clone/LICENSE;md5=411e33109fa516d190d232100fdc7f8e \
                    file://node_modules/json-stringify-safe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcryptjs/LICENSE;md5=d99a4f4253fea793a1256aef626aa6e5 \
                    file://node_modules/express/LICENSE;md5=5513c00a5c36cd361da863dd9aa8875d \
                    file://node_modules/express/node_modules/send/LICENSE;md5=df2b0938eba0709b77ac937e2d552b7a \
                    file://node_modules/express/node_modules/send/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/send/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/send/node_modules/fresh/LICENSE;md5=abf13d4b06f2210b2fab25b0f9641df7 \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/node_modules/statuses/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/send/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/express/node_modules/send/node_modules/destroy/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/send/node_modules/debug/node_modules/ms/LICENSE;md5=2be2157b55ea281b7f4969d7ba05eea2 \
                    file://node_modules/express/node_modules/send/node_modules/depd/LICENSE;md5=89378960d0c54c30539e50c7a78ce846 \
                    file://node_modules/express/node_modules/send/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/send/node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/express/node_modules/send/node_modules/ms/LICENSE;md5=2be2157b55ea281b7f4969d7ba05eea2 \
                    file://node_modules/express/node_modules/send/node_modules/mime/LICENSE;md5=8eab89930e0b484cd991ed4a155f74f7 \
                    file://node_modules/express/node_modules/send/node_modules/etag/LICENSE;md5=89378960d0c54c30539e50c7a78ce846 \
                    file://node_modules/express/node_modules/send/node_modules/statuses/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/send/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/parseurl/LICENSE;md5=f2a528765fa86a33fb7f85f3d9a1b5dd \
                    file://node_modules/express/node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/express/node_modules/methods/LICENSE;md5=c16a7dd9f946172f07086576d135d9d3 \
                    file://node_modules/express/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/fresh/LICENSE;md5=abf13d4b06f2210b2fab25b0f9641df7 \
                    file://node_modules/express/node_modules/vary/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/express/node_modules/merge-descriptors/LICENSE;md5=aaf57ba8c5c9bf256fea7e943991a81a \
                    file://node_modules/express/node_modules/proxy-addr/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/express/node_modules/proxy-addr/node_modules/forwarded/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/express/node_modules/proxy-addr/node_modules/ipaddr.js/LICENSE;md5=d9eb6ccfeb0da178937d5a70394647d3 \
                    file://node_modules/express/node_modules/debug/node_modules/ms/LICENSE;md5=2be2157b55ea281b7f4969d7ba05eea2 \
                    file://node_modules/express/node_modules/finalhandler/LICENSE;md5=5a8c677c8d98669640eac8d362cdd623 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/finalhandler/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/finalhandler/node_modules/debug/node_modules/ms/LICENSE;md5=2be2157b55ea281b7f4969d7ba05eea2 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/statuses/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/finalhandler/node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/express/node_modules/depd/LICENSE;md5=89378960d0c54c30539e50c7a78ce846 \
                    file://node_modules/express/node_modules/serve-static/LICENSE;md5=27b1707520b14d0bc890f4e75cd387b0 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/LICENSE;md5=df2b0938eba0709b77ac937e2d552b7a \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/fresh/LICENSE;md5=abf13d4b06f2210b2fab25b0f9641df7 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/node_modules/statuses/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/destroy/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/debug/node_modules/ms/LICENSE;md5=2be2157b55ea281b7f4969d7ba05eea2 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/depd/LICENSE;md5=89378960d0c54c30539e50c7a78ce846 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/ms/LICENSE.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/mime/LICENSE;md5=8eab89930e0b484cd991ed4a155f74f7 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/etag/LICENSE;md5=89378960d0c54c30539e50c7a78ce846 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/statuses/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/express/node_modules/serve-static/node_modules/send/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/serve-static/node_modules/parseurl/LICENSE;md5=f2a528765fa86a33fb7f85f3d9a1b5dd \
                    file://node_modules/express/node_modules/serve-static/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/serve-static/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/array-flatten/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
                    file://node_modules/express/node_modules/path-to-regexp/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
                    file://node_modules/express/node_modules/utils-merge/LICENSE;md5=f405e8bc5b8dd65fdb11cf3669fc209b \
                    file://node_modules/express/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/express/node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/express/node_modules/content-disposition/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/express/node_modules/etag/LICENSE;md5=89378960d0c54c30539e50c7a78ce846 \
                    file://node_modules/express/node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
                    file://node_modules/express/node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/express/node_modules/type-is/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/express/node_modules/type-is/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/express/node_modules/type-is/node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/express/node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/express/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/express/node_modules/accepts/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/express/node_modules/accepts/node_modules/negotiator/LICENSE;md5=6417a862a5e35c17c904d9dda2cbd499 \
                    file://node_modules/express/node_modules/accepts/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/express/node_modules/accepts/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/node-red-node-email/LICENSE;md5=2c0cb74248cfa16e787ab1cf4c16e94e \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/LICENSE;md5=dbed3866b24f3f6e1b51f9a78a077e54 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/libmime/LICENSE;md5=8ac9279ebdab473b8b5f0c1a65f5d8a8 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/libmime/node_modules/libqp/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/libmime/node_modules/libbase64/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/libmime/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/LICENSE;md5=e42b8189cb0589d6969be378527b49c1 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/libmime/LICENSE;md5=8ac9279ebdab473b8b5f0c1a65f5d8a8 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/libmime/node_modules/libqp/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/libmime/node_modules/libbase64/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/libmime/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/LICENSE;md5=8ac9279ebdab473b8b5f0c1a65f5d8a8 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/libmime/LICENSE;md5=8ac9279ebdab473b8b5f0c1a65f5d8a8 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/libmime/node_modules/libqp/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/libmime/node_modules/libbase64/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/libmime/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/libqp/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/libbase64/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/needle/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/needle/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/needle/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/mailcomposer/node_modules/buildmail/node_modules/addressparser/LICENSE;md5=92df5d1d0a7ed59110062d4b780821f3 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/nodemailer-direct-transport/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/nodemailer-direct-transport/node_modules/smtp-connection/LICENSE;md5=8ac9279ebdab473b8b5f0c1a65f5d8a8 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/nodemailer-smtp-transport/LICENSE;md5=24115bc5f2621ccccc533e207f5af97d \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/nodemailer-smtp-transport/node_modules/clone/LICENSE;md5=411e33109fa516d190d232100fdc7f8e \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/nodemailer-smtp-transport/node_modules/smtp-connection/LICENSE;md5=8ac9279ebdab473b8b5f0c1a65f5d8a8 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/nodemailer-smtp-transport/node_modules/nodemailer-wellknown/LICENSE;md5=bfdf9f972ae2f31a199a2f1a528d66f1 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/needle/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/needle/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/node-red-node-email/node_modules/nodemailer/node_modules/needle/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/node-red-node-email/node_modules/imap/LICENSE;md5=df3ad145c2acbfc4f246fa834a6675c7 \
                    file://node_modules/node-red-node-email/node_modules/imap/node_modules/readable-stream/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
                    file://node_modules/node-red-node-email/node_modules/imap/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=fcf5cfdc777e49f11402422c72a86f43 \
                    file://node_modules/node-red-node-email/node_modules/imap/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/node-red-node-email/node_modules/imap/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/node-red-node-email/node_modules/imap/node_modules/utf7/LICENSE;md5=1098f48dca90780ac00f1d85997c3f6a \
                    file://node_modules/node-red-node-email/node_modules/imap/node_modules/utf7/node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/node-red-node-email/node_modules/poplib/LICENSE;md5=b8a49f71bd6db4e5f60703c99d58e286 \
                    file://node_modules/node-red-node-email/node_modules/poplib/node_modules/optimist/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/node-red-node-email/node_modules/poplib/node_modules/optimist/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/node-red-node-email/node_modules/poplib/node_modules/optimist/node_modules/wordwrap/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/node-red-node-email/node_modules/mailparser/LICENSE;md5=e42b8189cb0589d6969be378527b49c1 \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/encoding/LICENSE;md5=a9992d70215d97e8b82d289cec0c1ffa \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/encoding/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/mimelib/LICENSE;md5=0fe3f49c89a663d74295183513bf60b3 \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/mimelib/node_modules/encoding/LICENSE;md5=a9992d70215d97e8b82d289cec0c1ffa \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/mimelib/node_modules/encoding/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/mimelib/node_modules/addressparser/LICENSE;md5=bf1db45206a67ab14ce4756294a8dc14 \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/uue/LICENSE;md5=59bca800be693681fca9b88cb0f61452 \
                    file://node_modules/node-red-node-email/node_modules/mailparser/node_modules/uue/node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/basic-auth/LICENSE;md5=42fffe6fe0b70501d52150ebb52113df \
                    file://node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/ws/node_modules/ultron/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/cookie-parser/LICENSE;md5=720bd7b9472a2297cd6820c73c71cf3e \
                    file://node_modules/cookie-parser/node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/sentiment/LICENSE.md;md5=48971111a3b92b39f389249f034c3b8b \
                    file://node_modules/node-red-node-feedparser/LICENSE;md5=2c0cb74248cfa16e787ab1cf4c16e94e \
                    file://node_modules/node-red-node-feedparser/node_modules/request/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/aws4/LICENSE;md5=ff6f181928a91d8631d565516b4db3cb \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/LICENSE;md5=e027b6d4642f6a1131d030b119fa8f50 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/node_modules/sntp/LICENSE;md5=6b3f1791e9fe721a645d793af56193c6 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/node_modules/sntp/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/node_modules/cryptiles/LICENSE;md5=6e2f87804ca8061967f7891dfb34f6f0 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/LICENSE;md5=d5c0c437eeeff35277efeadaec74e821 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/node_modules/boom/LICENSE;md5=d5c0c437eeeff35277efeadaec74e821 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/node_modules/boom/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/hawk/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/LICENSE;md5=bfa81591facc9224e4c7451c8dc12958 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/commander/LICENSE;md5=25851d4d10d6611a12d5571dab945a00 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/commander/node_modules/graceful-readlink/LICENSE;md5=b0270ddb7ee6643eee76e80113234806 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/pinkie-promise/license;md5=be72c3ad86c1c4e9578a1945b082b17d \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/pinkie-promise/node_modules/pinkie/license;md5=be72c3ad86c1c4e9578a1945b082b17d \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/chalk/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/chalk/node_modules/has-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/chalk/node_modules/has-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/chalk/node_modules/escape-string-regexp/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/chalk/node_modules/supports-color/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/chalk/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/chalk/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/chalk/node_modules/ansi-styles/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/is-my-json-valid/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/is-my-json-valid/node_modules/jsonpointer/LICENSE.md;md5=6f8a932f950cc1ae4cff952b7ef5abd6 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/is-my-json-valid/node_modules/generate-object-property/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/is-my-json-valid/node_modules/generate-object-property/node_modules/is-property/LICENSE;md5=34aed54d1454553d81a843e946b173a0 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/har-validator/node_modules/is-my-json-valid/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/tough-cookie/LICENSE;md5=ceb9c658d7a5d62bee6628c46832168e \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/tough-cookie/node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/stringstream/LICENSE.txt;md5=3b3d0996fc07ae2d89c4659b9ffcbe2e \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/json-stringify-safe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/form-data/License;md5=7aa505292e2636a9e59d4d3f258f4819 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/form-data/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/form-data/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/form-data/node_modules/async/LICENSE;md5=9ec5487258cc65072647c5488b4d59ad \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/form-data/node_modules/async/node_modules/lodash/LICENSE;md5=8f10c81975f996c3ba5b424884b4af96 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/form-data/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/form-data/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/oauth-sign/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/isstream/LICENSE.md;md5=1798150b9d70250c42b55b3530e6af2b \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/forever-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/is-typedarray/LICENSE.md;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/tunnel-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/bl/LICENSE.md;md5=7489efd5cf7c4575f9898b7eab7aeeb0 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/bl/node_modules/readable-stream/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=fcf5cfdc777e49f11402422c72a86f43 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/bl/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/bl/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/bl/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/bl/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/node-uuid/LICENSE.md;md5=465a37064da7d113df228e930a1cfdcd \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/jsprim/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/bcrypt-pbkdf/node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/dashdash/LICENSE.txt;md5=ebce61c1a0900d798daaf5853c69ce72 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/getpass/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/asn1/LICENSE;md5=5ce2f42143c298495637e28e40cd5462 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jodid25519/LICENSE;md5=5e6d2cd78a8664b38651e01b76a2323a \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jodid25519/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/LICENSE;md5=0d289b6d63cbcc18e4b2af9a5bd28b54 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/lib/LICENSE-jsbn;md5=32052d48bacabd1c02e56c6889082a27 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/caseless/LICENSE;md5=e9dadf023ba6ebd98e3e0acb6e2470e3 \
                    file://node_modules/node-red-node-feedparser/node_modules/request/node_modules/aws-sign2/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-feedparser/node_modules/feedparser/LICENSE;md5=d349e375306c8274296c611d9bd9fe11 \
                    file://node_modules/node-red-node-feedparser/node_modules/feedparser/node_modules/readable-stream/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
                    file://node_modules/node-red-node-feedparser/node_modules/feedparser/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=fcf5cfdc777e49f11402422c72a86f43 \
                    file://node_modules/node-red-node-feedparser/node_modules/feedparser/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/node-red-node-feedparser/node_modules/feedparser/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/node-red-node-feedparser/node_modules/feedparser/node_modules/sax/LICENSE-W3C.html;md5=8668c6754c761b67065d514f927fa556 \
                    file://node_modules/node-red-node-feedparser/node_modules/feedparser/node_modules/sax/LICENSE;md5=f9827a729b80dc4ccea991290dc88f05 \
                    file://node_modules/cheerio/node_modules/lodash.pick/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/lodash.bind/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/lodash.reduce/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/lodash.flatten/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/lodash.defaults/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/lodash.merge/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/htmlparser2/LICENSE;md5=10e03952c97f225d4229d7524619eb7f \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/domelementtype/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/domutils/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/domutils/node_modules/domelementtype/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/domutils/node_modules/dom-serializer/LICENSE;md5=ba3390a22fe1d127f3522ac8ef1bd1a0 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/domutils/node_modules/dom-serializer/node_modules/domelementtype/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/domutils/node_modules/dom-serializer/node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/domhandler/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/domhandler/node_modules/domelementtype/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/htmlparser2/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/cheerio/node_modules/lodash.reject/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/lodash.map/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/lodash.foreach/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/lodash.assignin/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/css-select/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/css-select/node_modules/css-what/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/css-select/node_modules/domutils/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/css-select/node_modules/domutils/node_modules/domelementtype/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/css-select/node_modules/domutils/node_modules/dom-serializer/LICENSE;md5=ba3390a22fe1d127f3522ac8ef1bd1a0 \
                    file://node_modules/cheerio/node_modules/css-select/node_modules/domutils/node_modules/dom-serializer/node_modules/domelementtype/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/css-select/node_modules/domutils/node_modules/dom-serializer/node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/lodash.filter/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/cheerio/node_modules/dom-serializer/LICENSE;md5=ba3390a22fe1d127f3522ac8ef1bd1a0 \
                    file://node_modules/cheerio/node_modules/dom-serializer/node_modules/domelementtype/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/dom-serializer/node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/node_modules/lodash.some/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/js-yaml/node_modules/argparse/LICENSE;md5=a2f2590d8d82b0fa2b3e2fc5c69d2b81 \
                    file://node_modules/js-yaml/node_modules/argparse/node_modules/sprintf-js/LICENSE;md5=ab40451de4e35c90f1b663b4fbd314a9 \
                    file://node_modules/js-yaml/node_modules/esprima/LICENSE.BSD;md5=3e0ad2b4a2d836d43cf3c7b46c34512c \
                    file://node_modules/node-red-node-twitter/LICENSE;md5=2c0cb74248cfa16e787ab1cf4c16e94e \
                    file://node_modules/node-red-node-twitter/node_modules/request/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/aws4/LICENSE;md5=ff6f181928a91d8631d565516b4db3cb \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/LICENSE;md5=e027b6d4642f6a1131d030b119fa8f50 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/node_modules/sntp/LICENSE;md5=6b3f1791e9fe721a645d793af56193c6 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/node_modules/sntp/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/node_modules/cryptiles/LICENSE;md5=6e2f87804ca8061967f7891dfb34f6f0 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/LICENSE;md5=d5c0c437eeeff35277efeadaec74e821 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/node_modules/boom/LICENSE;md5=d5c0c437eeeff35277efeadaec74e821 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/node_modules/boom/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/hawk/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/har-validator/LICENSE;md5=bfa81591facc9224e4c7451c8dc12958 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/har-validator/node_modules/har-schema/LICENSE;md5=bfa81591facc9224e4c7451c8dc12958 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/har-validator/node_modules/ajv/LICENSE;md5=715855234c57d97032971adfc0608a07 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/har-validator/node_modules/ajv/node_modules/co/LICENSE;md5=1cb994f27906c83d46a3cc6d9e1d8d6c \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/har-validator/node_modules/ajv/node_modules/json-stable-stringify/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/tough-cookie/LICENSE;md5=ceb9c658d7a5d62bee6628c46832168e \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/tough-cookie/node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/stringstream/LICENSE.txt;md5=3b3d0996fc07ae2d89c4659b9ffcbe2e \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/performance-now/license.txt;md5=4c1faf980adc2df1831ff8c0e47897e8 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/json-stringify-safe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/form-data/License;md5=7aa505292e2636a9e59d4d3f258f4819 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/form-data/node_modules/asynckit/LICENSE;md5=177bc287fb9558bf3ea50b440c1c86ff \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/form-data/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/form-data/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/form-data/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/form-data/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/oauth-sign/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/isstream/LICENSE.md;md5=1798150b9d70250c42b55b3530e6af2b \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/forever-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/is-typedarray/LICENSE.md;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/tunnel-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/tunnel-agent/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/uuid/LICENSE.md;md5=c9420736e23afb538ba5fbe44197f0b4 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/jsprim/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/bcrypt-pbkdf/node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/dashdash/LICENSE.txt;md5=ebce61c1a0900d798daaf5853c69ce72 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/getpass/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/asn1/LICENSE;md5=5ce2f42143c298495637e28e40cd5462 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jodid25519/LICENSE;md5=5e6d2cd78a8664b38651e01b76a2323a \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jodid25519/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/LICENSE;md5=0d289b6d63cbcc18e4b2af9a5bd28b54 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/lib/LICENSE-jsbn;md5=32052d48bacabd1c02e56c6889082a27 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/caseless/LICENSE;md5=e9dadf023ba6ebd98e3e0acb6e2470e3 \
                    file://node_modules/node-red-node-twitter/node_modules/request/node_modules/aws-sign2/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/node-red-node-twitter/node_modules/twitter-ng/LICENSE;md5=cac5284e7ebec9e0d4115690b5541c53 \
                    file://node_modules/node-red-node-twitter/node_modules/twitter-ng/node_modules/oauth/LICENSE;md5=eb77dec1db99ddcb43808fd5a490c035 \
                    file://node_modules/node-red-node-twitter/node_modules/oauth/LICENSE;md5=eb77dec1db99ddcb43808fd5a490c035 \
                    file://node_modules/is-utf8/LICENSE;md5=10d1495ba46609e55e586ab71fa81f45 \
                    file://node_modules/nopt/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/nopt/node_modules/abbrev/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/body-parser/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/body-parser/node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/body-parser/node_modules/on-finished/node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/body-parser/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/body-parser/node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/body-parser/node_modules/http-errors/node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/body-parser/node_modules/http-errors/node_modules/statuses/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/body-parser/node_modules/http-errors/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/body-parser/node_modules/debug/node_modules/ms/LICENSE;md5=2be2157b55ea281b7f4969d7ba05eea2 \
                    file://node_modules/body-parser/node_modules/depd/LICENSE;md5=89378960d0c54c30539e50c7a78ce846 \
                    file://node_modules/body-parser/node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
                    file://node_modules/body-parser/node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/body-parser/node_modules/type-is/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/body-parser/node_modules/type-is/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/body-parser/node_modules/type-is/node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/body-parser/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/body-parser/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/body-parser/node_modules/raw-body/LICENSE;md5=c970d30155ebbdb1903e6de8c0666e18 \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/body-parser/node_modules/raw-body/node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/cron/node_modules/moment-timezone/LICENSE;md5=3577232a0c0c3cb5271d3d25cd32fe4e \
                    file://node_modules/cron/node_modules/moment-timezone/node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/oauth2orize/LICENSE;md5=a39b08d52a8e25a6791d6102a5657aa8 \
                    file://node_modules/oauth2orize/node_modules/uid2/LICENSE;md5=dd54d0741106ff4193bcecb833f6e350 \
                    file://node_modules/oauth2orize/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/oauth2orize/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/oauth2orize/node_modules/utils-merge/LICENSE;md5=f405e8bc5b8dd65fdb11cf3669fc209b \
                    file://node_modules/node-red-node-rbe/LICENSE;md5=2c0cb74248cfa16e787ab1cf4c16e94e \
                    file://node_modules/on-headers/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/cors/LICENSE;md5=43b5353b7cba327feed269fae6433cc9 \
                    file://node_modules/cors/node_modules/vary/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/fs-extra/LICENSE;md5=e3f4c24990b451449e8a23e77609a1b5 \
                    file://node_modules/fs-extra/node_modules/klaw/LICENSE;md5=697a7a0c34115889f2e13e78c7d0bc9b \
                    file://node_modules/fs-extra/node_modules/klaw/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/fs-extra/node_modules/jsonfile/LICENSE;md5=423f377ade95936f6fe009b1c137bfdb \
                    file://node_modules/fs-extra/node_modules/jsonfile/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/fs-extra/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/fs.notify/node_modules/retry/License;md5=c40fe50d231414ad1bc68e8965e7e95e \
                    file://node_modules/fs.notify/node_modules/async/LICENSE;md5=64a378b2b01424fe22d54bc626175994 \
                    file://node_modules/bcrypt/LICENSE;md5=4665b5424ab734549385bae891f8d35d \
                    file://node_modules/bcrypt/node_modules/nan/LICENSE.md;md5=365dd94f3b619ca5566e5fb51f32c0e6 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/LICENSE;md5=7e13c3cf883a44ebcc74a8f568c0f6fb \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/aws4/LICENSE;md5=ff6f181928a91d8631d565516b4db3cb \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/LICENSE;md5=e027b6d4642f6a1131d030b119fa8f50 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/sntp/LICENSE;md5=6b3f1791e9fe721a645d793af56193c6 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/sntp/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/LICENSE;md5=6e2f87804ca8061967f7891dfb34f6f0 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/LICENSE;md5=d5c0c437eeeff35277efeadaec74e821 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/cryptiles/node_modules/boom/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/boom/LICENSE;md5=d5c0c437eeeff35277efeadaec74e821 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/boom/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/hawk/node_modules/hoek/LICENSE;md5=0ae863d44c9a840e5cc04241d8d9c736 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/LICENSE;md5=bfa81591facc9224e4c7451c8dc12958 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/har-schema/LICENSE;md5=bfa81591facc9224e4c7451c8dc12958 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/ajv/LICENSE;md5=715855234c57d97032971adfc0608a07 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/ajv/node_modules/co/LICENSE;md5=1cb994f27906c83d46a3cc6d9e1d8d6c \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/har-validator/node_modules/ajv/node_modules/json-stable-stringify/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tough-cookie/LICENSE;md5=ceb9c658d7a5d62bee6628c46832168e \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tough-cookie/node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/stringstream/LICENSE.txt;md5=3b3d0996fc07ae2d89c4659b9ffcbe2e \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/performance-now/license.txt;md5=4c1faf980adc2df1831ff8c0e47897e8 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/json-stringify-safe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/License;md5=7aa505292e2636a9e59d4d3f258f4819 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/asynckit/LICENSE;md5=177bc287fb9558bf3ea50b440c1c86ff \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/mime-types/node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/form-data/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/oauth-sign/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/isstream/LICENSE.md;md5=1798150b9d70250c42b55b3530e6af2b \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/forever-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/is-typedarray/LICENSE.md;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tunnel-agent/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/tunnel-agent/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/uuid/LICENSE.md;md5=c9420736e23afb538ba5fbe44197f0b4 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/jsprim/node_modules/verror/node_modules/extsprintf/LICENSE;md5=bc3c23d98d7aa86bbf232058884e19b2 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/bcrypt-pbkdf/node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/dashdash/LICENSE.txt;md5=ebce61c1a0900d798daaf5853c69ce72 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/getpass/LICENSE;md5=38ecf0a3a3894f404ca99c2a08924afc \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/asn1/LICENSE;md5=5ce2f42143c298495637e28e40cd5462 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jodid25519/LICENSE;md5=5e6d2cd78a8664b38651e01b76a2323a \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jodid25519/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/tweetnacl/LICENSE;md5=911690f51af322440237a253d695d19f \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/LICENSE;md5=0d289b6d63cbcc18e4b2af9a5bd28b54 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/lib/LICENSE-jsbn;md5=32052d48bacabd1c02e56c6889082a27 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/http-signature/node_modules/sshpk/node_modules/ecc-jsbn/node_modules/jsbn/LICENSE;md5=c6ea389b6b52325149beeec27075c5ac \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/combined-stream/node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/caseless/LICENSE;md5=e9dadf023ba6ebd98e3e0acb6e2470e3 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/request/node_modules/aws-sign2/LICENSE;md5=f3f8ead5440d1c311b45be065d135d90 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/LICENSE;md5=bbd174e5c1525a215e2f38ebfcca16e9 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=fcf5cfdc777e49f11402422c72a86f43 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/buffer-shims/license.md;md5=e04ef9ec24d382b7576c997066a44835 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/debug/node_modules/ms/LICENSE;md5=2be2157b55ea281b7f4969d7ba05eea2 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/uid-number/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/fstream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/fstream-ignore/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/LICENSE;md5=34c65f5b9b91f31827910d3b54bd6497 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/fstream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/block-stream/LICENCE;md5=c695aba12d799c74e770d90e1c5d59aa \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/block-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/block-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/tar/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar-pack/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/LICENSE.BSD;md5=e7a2a325a0069e82aff675bbf74464a0 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/node_modules/strip-json-comments/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/node_modules/deep-extend/LICENSE;md5=74959162613f2777f3ef55bdb8b74c89 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rc/node_modules/ini/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/nopt/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/nopt/node_modules/abbrev/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/LICENSE;md5=34c65f5b9b91f31827910d3b54bd6497 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/rimraf/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/fstream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/block-stream/LICENCE;md5=c695aba12d799c74e770d90e1c5d59aa \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/block-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/block-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/tar/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/set-blocking/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/is-fullwidth-code-point/node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/wide-align/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/is-fullwidth-code-point/node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/string-width/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/aproba/LICENSE;md5=9d215c9223fbef14a4642cc450e7ed4b \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/signal-exit/LICENSE.txt;md5=e29e20260a1c78dba16a233048565cde \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/strip-ansi/node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/has-unicode/LICENSE;md5=2bab5b1c26e9c44fc4e489bb98cfb196 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/gauge/node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/LICENSE;md5=039a23da29f56411e6d75d7b7bc9de13 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/delegates/License;md5=039225978c07bc42e8c0ef2f72b81c09 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/are-we-there-yet/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/bcrypt/node_modules/node-pre-gyp/node_modules/npmlog/node_modules/console-control-strings/LICENSE;md5=43abbc6f9093aea69560715033788727 \
                    file://node_modules/follow-redirects/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/follow-redirects/node_modules/debug/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/mqtt/LICENSE.md;md5=261aa46f11e9a7bdbea1dea7eb8bcb6c \
                    file://node_modules/mqtt/node_modules/commist/LICENSE;md5=3f047b8c72633e56a5d2bddc7feaa719 \
                    file://node_modules/mqtt/node_modules/commist/node_modules/leven/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/mqtt/node_modules/commist/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/mqtt/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/mqtt/node_modules/help-me/LICENSE;md5=6c5e18034ed4abefcb9ac97254596680 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/LICENSE;md5=59d5f6a97c4befff1e4f1c67abc598c2 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/extend/LICENSE;md5=33d9f7a91df276ec16aa941032ee1476 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/LICENSE;md5=64386b1e25291dbfa6fc2a6631a8eef5 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/json-stable-stringify/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/LICENSE.md;md5=12ef18138f1e1743e5d57ffef544235b \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/LICENSE.html;md5=bb8031aeb39f1781e22716925f7589ac \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/unique-stream/node_modules/through2-filter/node_modules/through2/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob-parent/LICENSE;md5=429b0fedc27562e9e8deba9a9585396d \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob-parent/node_modules/is-glob/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob-parent/node_modules/is-glob/node_modules/is-extglob/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob-parent/node_modules/path-dirname/license;md5=83e325e26e7a045eef3df8d1082df8c0 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/stream-shift/LICENSE;md5=42014010547e55bd3bcac2fec8c45624 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/duplexify/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/pump/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/pump/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/pump/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/pump/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/pump/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/pumpify/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/node_modules/is-absolute/LICENSE;md5=e51d1a9544989319e6173197943e1cad \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/node_modules/is-absolute/node_modules/is-relative/LICENSE;md5=322b35f66850c3db886ad69d3edef5a0 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/node_modules/is-absolute/node_modules/is-relative/node_modules/is-unc-path/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/node_modules/is-absolute/node_modules/is-relative/node_modules/is-unc-path/node_modules/unc-path-regex/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/node_modules/is-absolute/node_modules/is-windows/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/to-absolute-glob/node_modules/is-negated-glob/LICENSE;md5=d5d7b190ec11a5e3199c3b3b45cde690 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/inflight/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/inflight/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/inflight/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/minimatch/node_modules/brace-expansion/node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/glob/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/LICENSE;md5=2c136e62d89cbaf1bb1aa0e6002c3c5b \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/ordered-read-streams/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/remove-trailing-separator/license;md5=294c1c7712f9be26cef730b5ad95a6a5 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/glob-stream/node_modules/is-negated-glob/LICENSE;md5=d5d7b190ec11a5e3199c3b3b45cde690 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/LICENSE.md;md5=12ef18138f1e1743e5d57ffef544235b \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/LICENSE.html;md5=bb8031aeb39f1781e22716925f7589ac \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/through2/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/help-me/node_modules/callback-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/split2/LICENSE;md5=3dc087ebf2e241fb54b937c0b9a11cf5 \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/LICENSE.md;md5=12ef18138f1e1743e5d57ffef544235b \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/LICENSE.html;md5=bb8031aeb39f1781e22716925f7589ac \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/split2/node_modules/through2/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/reinterval/LICENSE;md5=c65ef22a386436c433298ca42418c200 \
                    file://node_modules/mqtt/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/mqtt/node_modules/mqtt-packet/LICENSE.md;md5=622e77e45833bb4f785aebc7e41c0bdb \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/LICENSE.md;md5=e58dc7a94bb9decf6a7b2ff97d22b213 \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/bl/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/mqtt-packet/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/websocket-stream/LICENSE;md5=17c1dd792579df06dfb25f64c81968ec \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/stream-shift/LICENSE;md5=42014010547e55bd3bcac2fec8c45624 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/duplexify/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/ws/node_modules/ultron/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/LICENSE.md;md5=12ef18138f1e1743e5d57ffef544235b \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/LICENSE.html;md5=bb8031aeb39f1781e22716925f7589ac \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/websocket-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mqtt/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mqtt/node_modules/pump/node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/mqtt/node_modules/pump/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/pump/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/pump/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/pump/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt/node_modules/concat-stream/LICENSE;md5=3ad90c134f824ddfcea611ee1fa567a8 \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/readable-stream/node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/readable-stream/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/readable-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/typedarray/LICENSE;md5=6085b70b74c7dcf7df4e955725e3153d \
                    file://node_modules/mqtt/node_modules/concat-stream/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/mqtt/node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/raw-body/LICENSE;md5=c970d30155ebbdb1903e6de8c0666e18 \
                    file://node_modules/raw-body/node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/raw-body/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/raw-body/node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739"

SRC_URI = "npm://registry.npmjs.org;name=node-red;version=${PV}"

NPM_SHRINKWRAP := "${THISDIR}/${PN}/npm-shrinkwrap.json"
NPM_LOCKDOWN := "${THISDIR}/${PN}/lockdown.json"

inherit npm-manual-inst

# Must be set after inherit npm since that itself sets S
S = "${WORKDIR}/npmpkg"
LICENSE_${PN}-basic-auth = "MIT"
LICENSE_${PN}-bcrypt-bindings = "MIT"
LICENSE_${PN}-bcrypt-nan = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-mkdirp-minimist = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-mkdirp = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-nopt-abbrev = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-nopt = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-delegates = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-isarray = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet-readable-stream = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-are-we-there-yet = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-console-control-strings = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-aproba = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-console-control-strings = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-has-unicode = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-object-assign = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-signal-exit = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-string-width-code-point-at = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-string-width-is-fullwidth-code-point-number-is-nan = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-string-width-strip-ansi = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-string-width = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-strip-ansi = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-code-point-at = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-is-fullwidth-code-point-number-is-nan = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width-strip-ansi = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-wide-align-string-width = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge-wide-align = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-gauge = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog-set-blocking = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-npmlog = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rc-deep-extend = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-rc-ini = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rc-minimist = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-rc-strip-json-comments = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-rc = "Apache-2.0 MIT BSD-2-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-aws-sign2 = "Apache-2.0"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-aws4 = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-caseless = "Apache-2.0"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-combined-stream = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-extend = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-forever-agent = "Apache-2.0"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-form-data-asynckit = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-form-data-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-form-data-combined-stream = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-form-data-mime-types-mime-db = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-form-data-mime-types = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-form-data = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-har-validator-ajv-co = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-har-validator-ajv-json-stable-stringify-jsonify = "PD"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-har-validator-ajv-json-stable-stringify = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-har-validator-ajv = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-har-validator-har-schema = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-har-validator = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk-boom-hoek = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk-boom = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk-cryptiles-boom-hoek = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk-cryptiles-boom = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk-cryptiles = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk-hoek = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk-sntp-hoek = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk-sntp = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-hawk = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-assert-plus = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-jsprim-assert-plus = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-jsprim-extsprintf = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-jsprim-json-schema = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-jsprim-verror-extsprintf = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-jsprim-verror = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-jsprim = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-asn1 = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-assert-plus = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-bcrypt-pbkdf-tweetnacl = "PD"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-bcrypt-pbkdf = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-dashdash-assert-plus = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-dashdash = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-ecc-jsbn-jsbn = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-ecc-jsbn = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-getpass-assert-plus = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-getpass = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-jodid25519-jsbn = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-jodid25519 = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-jsbn = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk-tweetnacl = "PD"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature-sshpk = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-http-signature = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-is-typedarray = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-isstream = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-json-stringify-safe = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-mime-types-mime-db = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-mime-types = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-oauth-sign = "Apache-2.0"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-performance-now = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-qs = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-safe-buffer = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-stringstream = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-tough-cookie-punycode = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-tough-cookie = "BSD-3-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-tunnel-agent-safe-buffer = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-tunnel-agent = "Apache-2.0"
LICENSE_${PN}-bcrypt-node-pre-gyp-request-uuid = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-request = "Apache-2.0"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf-glob = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-rimraf = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-semver = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-block-stream-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-block-stream = "ISC BSD-2-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-graceful-fs = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-mkdirp-minimist = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-mkdirp = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf-glob = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream-rimraf = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-fstream = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-debug-ms = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-debug = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-graceful-fs = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-graceful-fs = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-mkdirp-minimist = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-mkdirp = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf-glob = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream-rimraf = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-fstream = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore-minimatch = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-ignore = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-mkdirp-minimist = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-mkdirp = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf-glob = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream-rimraf = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-fstream = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-readable-stream-buffer-shims = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-readable-stream-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-readable-stream-isarray = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-readable-stream = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf-glob = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-rimraf = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-block-stream-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-block-stream = "ISC BSD-2-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-graceful-fs = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-mkdirp-minimist = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-mkdirp = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-fs.realpath = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inflight-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inflight = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-minimatch = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-once-wrappy = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-once = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob-path-is-absolute = "MIT"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf-glob = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream-rimraf = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-fstream = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar-inherits = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-tar = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack-uid-number = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar-pack = "BSD-2-Clause"
LICENSE_${PN}-bcrypt-node-pre-gyp-tar = "ISC"
LICENSE_${PN}-bcrypt-node-pre-gyp = "BSD-3-Clause"
LICENSE_${PN}-bcryptjs = "MIT"
LICENSE_${PN}-bcrypt = "MIT"
LICENSE_${PN}-body-parser-bytes = "MIT"
LICENSE_${PN}-body-parser-content-type = "MIT"
LICENSE_${PN}-body-parser-debug-ms = "MIT"
LICENSE_${PN}-body-parser-debug = "MIT"
LICENSE_${PN}-body-parser-depd = "MIT"
LICENSE_${PN}-body-parser-http-errors-inherits = "ISC"
LICENSE_${PN}-body-parser-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-body-parser-http-errors-statuses = "MIT"
LICENSE_${PN}-body-parser-http-errors = "MIT"
LICENSE_${PN}-body-parser-iconv-lite = "MIT"
LICENSE_${PN}-body-parser-on-finished-ee-first = "MIT"
LICENSE_${PN}-body-parser-on-finished = "MIT"
LICENSE_${PN}-body-parser-qs = "BSD-3-Clause"
LICENSE_${PN}-body-parser-raw-body-bytes = "MIT"
LICENSE_${PN}-body-parser-raw-body-iconv-lite = "MIT"
LICENSE_${PN}-body-parser-raw-body-unpipe = "MIT"
LICENSE_${PN}-body-parser-raw-body = "MIT"
LICENSE_${PN}-body-parser-type-is-media-typer = "MIT"
LICENSE_${PN}-body-parser-type-is-mime-types-mime-db = "MIT"
LICENSE_${PN}-body-parser-type-is-mime-types = "MIT"
LICENSE_${PN}-body-parser-type-is = "MIT"
LICENSE_${PN}-body-parser = "MIT"
LICENSE_${PN}-cheerio-css-select-boolbase = "ISC"
LICENSE_${PN}-cheerio-css-select-css-what = "BSD-2-Clause"
LICENSE_${PN}-cheerio-css-select-domutils-dom-serializer-domelementtype = "BSD-2-Clause"
LICENSE_${PN}-cheerio-css-select-domutils-dom-serializer-entities = "BSD-2-Clause"
LICENSE_${PN}-cheerio-css-select-domutils-dom-serializer = "MIT"
LICENSE_${PN}-cheerio-css-select-domutils-domelementtype = "BSD-2-Clause"
LICENSE_${PN}-cheerio-css-select-domutils = "BSD-2-Clause"
LICENSE_${PN}-cheerio-css-select-nth-check-boolbase = "ISC"
LICENSE_${PN}-cheerio-css-select-nth-check = "BSD"
LICENSE_${PN}-cheerio-css-select = "BSD-2-Clause"
LICENSE_${PN}-cheerio-dom-serializer-domelementtype = "BSD-2-Clause"
LICENSE_${PN}-cheerio-dom-serializer-entities = "BSD-2-Clause"
LICENSE_${PN}-cheerio-dom-serializer = "MIT"
LICENSE_${PN}-cheerio-entities = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-domelementtype = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-domhandler-domelementtype = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-domhandler = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-domutils-dom-serializer-domelementtype = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-domutils-dom-serializer-entities = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-domutils-dom-serializer = "MIT"
LICENSE_${PN}-cheerio-htmlparser2-domutils-domelementtype = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-domutils = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-entities = "BSD-2-Clause"
LICENSE_${PN}-cheerio-htmlparser2-inherits = "ISC"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream-inherits = "ISC"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream-isarray = "MIT"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-cheerio-htmlparser2-readable-stream = "MIT"
LICENSE_${PN}-cheerio-htmlparser2 = "MIT"
LICENSE_${PN}-cheerio-lodash.assignin = "MIT"
LICENSE_${PN}-cheerio-lodash.bind = "MIT"
LICENSE_${PN}-cheerio-lodash.defaults = "MIT"
LICENSE_${PN}-cheerio-lodash.filter = "MIT"
LICENSE_${PN}-cheerio-lodash.flatten = "MIT"
LICENSE_${PN}-cheerio-lodash.foreach = "MIT"
LICENSE_${PN}-cheerio-lodash.map = "MIT"
LICENSE_${PN}-cheerio-lodash.merge = "MIT"
LICENSE_${PN}-cheerio-lodash.pick = "MIT"
LICENSE_${PN}-cheerio-lodash.reduce = "MIT"
LICENSE_${PN}-cheerio-lodash.reject = "MIT"
LICENSE_${PN}-cheerio-lodash.some = "MIT"
LICENSE_${PN}-cheerio = "MIT"
LICENSE_${PN}-clone = "MIT"
LICENSE_${PN}-cookie-parser-cookie-signature = "MIT"
LICENSE_${PN}-cookie-parser-cookie = "MIT"
LICENSE_${PN}-cookie-parser = "MIT"
LICENSE_${PN}-cors-vary = "MIT"
LICENSE_${PN}-cors = "MIT"
LICENSE_${PN}-cron-moment-timezone-moment = "MIT"
LICENSE_${PN}-cron-moment-timezone = "MIT"
LICENSE_${PN}-cron = "MIT"
LICENSE_${PN}-express-accepts-mime-types-mime-db = "MIT"
LICENSE_${PN}-express-accepts-mime-types = "MIT"
LICENSE_${PN}-express-accepts-negotiator = "MIT"
LICENSE_${PN}-express-accepts = "MIT"
LICENSE_${PN}-express-array-flatten = "MIT"
LICENSE_${PN}-express-content-disposition = "MIT"
LICENSE_${PN}-express-content-type = "MIT"
LICENSE_${PN}-express-cookie-signature = "MIT"
LICENSE_${PN}-express-cookie = "MIT"
LICENSE_${PN}-express-debug-ms = "MIT"
LICENSE_${PN}-express-debug = "MIT"
LICENSE_${PN}-express-depd = "MIT"
LICENSE_${PN}-express-encodeurl = "MIT"
LICENSE_${PN}-express-escape-html = "MIT"
LICENSE_${PN}-express-etag = "MIT"
LICENSE_${PN}-express-finalhandler-debug-ms = "MIT"
LICENSE_${PN}-express-finalhandler-debug = "MIT"
LICENSE_${PN}-express-finalhandler-escape-html = "MIT"
LICENSE_${PN}-express-finalhandler-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-finalhandler-on-finished = "MIT"
LICENSE_${PN}-express-finalhandler-statuses = "MIT"
LICENSE_${PN}-express-finalhandler-unpipe = "MIT"
LICENSE_${PN}-express-finalhandler = "MIT"
LICENSE_${PN}-express-fresh = "MIT"
LICENSE_${PN}-express-merge-descriptors = "MIT"
LICENSE_${PN}-express-methods = "MIT"
LICENSE_${PN}-express-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-on-finished = "MIT"
LICENSE_${PN}-express-parseurl = "MIT"
LICENSE_${PN}-express-path-to-regexp = "MIT"
LICENSE_${PN}-express-proxy-addr-forwarded = "MIT"
LICENSE_${PN}-express-proxy-addr-ipaddr.js = "MIT"
LICENSE_${PN}-express-proxy-addr = "MIT"
LICENSE_${PN}-express-qs = "BSD-3-Clause"
LICENSE_${PN}-express-range-parser = "MIT"
LICENSE_${PN}-express-send-debug-ms = "MIT"
LICENSE_${PN}-express-send-debug = "MIT"
LICENSE_${PN}-express-send-depd = "MIT"
LICENSE_${PN}-express-send-destroy = "MIT"
LICENSE_${PN}-express-send-encodeurl = "MIT"
LICENSE_${PN}-express-send-escape-html = "MIT"
LICENSE_${PN}-express-send-etag = "MIT"
LICENSE_${PN}-express-send-fresh = "MIT"
LICENSE_${PN}-express-send-http-errors-inherits = "ISC"
LICENSE_${PN}-express-send-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-express-send-http-errors-statuses = "MIT"
LICENSE_${PN}-express-send-http-errors = "MIT"
LICENSE_${PN}-express-send-mime = "MIT"
LICENSE_${PN}-express-send-ms = "MIT"
LICENSE_${PN}-express-send-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-send-on-finished = "MIT"
LICENSE_${PN}-express-send-range-parser = "MIT"
LICENSE_${PN}-express-send-statuses = "MIT"
LICENSE_${PN}-express-send = "MIT"
LICENSE_${PN}-express-serve-static-encodeurl = "MIT"
LICENSE_${PN}-express-serve-static-escape-html = "MIT"
LICENSE_${PN}-express-serve-static-parseurl = "MIT"
LICENSE_${PN}-express-serve-static-send-debug-ms = "MIT"
LICENSE_${PN}-express-serve-static-send-debug = "MIT"
LICENSE_${PN}-express-serve-static-send-depd = "MIT"
LICENSE_${PN}-express-serve-static-send-destroy = "MIT"
LICENSE_${PN}-express-serve-static-send-encodeurl = "MIT"
LICENSE_${PN}-express-serve-static-send-escape-html = "MIT"
LICENSE_${PN}-express-serve-static-send-etag = "MIT"
LICENSE_${PN}-express-serve-static-send-fresh = "MIT"
LICENSE_${PN}-express-serve-static-send-http-errors-inherits = "ISC"
LICENSE_${PN}-express-serve-static-send-http-errors-setprototypeof = "ISC"
LICENSE_${PN}-express-serve-static-send-http-errors-statuses = "MIT"
LICENSE_${PN}-express-serve-static-send-http-errors = "MIT"
LICENSE_${PN}-express-serve-static-send-mime = "MIT"
LICENSE_${PN}-express-serve-static-send-ms = "MIT"
LICENSE_${PN}-express-serve-static-send-on-finished-ee-first = "MIT"
LICENSE_${PN}-express-serve-static-send-on-finished = "MIT"
LICENSE_${PN}-express-serve-static-send-range-parser = "MIT"
LICENSE_${PN}-express-serve-static-send-statuses = "MIT"
LICENSE_${PN}-express-serve-static-send = "MIT"
LICENSE_${PN}-express-serve-static = "MIT"
LICENSE_${PN}-express-type-is-media-typer = "MIT"
LICENSE_${PN}-express-type-is-mime-types-mime-db = "MIT"
LICENSE_${PN}-express-type-is-mime-types = "MIT"
LICENSE_${PN}-express-type-is = "MIT"
LICENSE_${PN}-express-utils-merge = "MIT"
LICENSE_${PN}-express-vary = "MIT"
LICENSE_${PN}-express = "MIT"
LICENSE_${PN}-follow-redirects-debug-ms = "MIT"
LICENSE_${PN}-follow-redirects-debug = "MIT"
LICENSE_${PN}-follow-redirects = "MIT"
LICENSE_${PN}-fs-extra-graceful-fs = "ISC"
LICENSE_${PN}-fs-extra-jsonfile-graceful-fs = "ISC"
LICENSE_${PN}-fs-extra-jsonfile = "MIT"
LICENSE_${PN}-fs-extra-klaw-graceful-fs = "ISC"
LICENSE_${PN}-fs-extra-klaw = "MIT"
LICENSE_${PN}-fs-extra = "MIT"
LICENSE_${PN}-fs.notify-async = "MIT"
LICENSE_${PN}-fs.notify-retry = "MIT"
LICENSE_${PN}-fs.notify = "MIT"
LICENSE_${PN}-i18next-cookies-depd = "MIT"
LICENSE_${PN}-i18next-cookies-keygrip = "MIT"
LICENSE_${PN}-i18next-cookies = "MIT"
LICENSE_${PN}-i18next-i18next-client = "MIT"
LICENSE_${PN}-i18next-json5 = "MIT"
LICENSE_${PN}-i18next = "MIT"
LICENSE_${PN}-is-utf8 = "MIT"
LICENSE_${PN}-js-yaml-argparse-sprintf-js = "BSD-3-Clause"
LICENSE_${PN}-js-yaml-argparse = "MIT"
LICENSE_${PN}-js-yaml-esprima = "BSD-2-Clause"
LICENSE_${PN}-js-yaml = "MIT"
LICENSE_${PN}-json-stringify-safe = "ISC"
LICENSE_${PN}-jsonata = "MIT"
LICENSE_${PN}-media-typer = "MIT"
LICENSE_${PN}-mqtt-commist-leven = "MIT"
LICENSE_${PN}-mqtt-commist-minimist = "MIT"
LICENSE_${PN}-mqtt-commist = "MIT"
LICENSE_${PN}-mqtt-concat-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-concat-stream-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-concat-stream-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-concat-stream-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-concat-stream-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-concat-stream-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-concat-stream-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-concat-stream-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-concat-stream-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-concat-stream-readable-stream = "MIT"
LICENSE_${PN}-mqtt-concat-stream-typedarray = "MIT"
LICENSE_${PN}-mqtt-concat-stream = "MIT"
LICENSE_${PN}-mqtt-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-end-of-stream-once = "ISC"
LICENSE_${PN}-mqtt-end-of-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream-readable-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-callback-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-extend = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-fs.realpath = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-inflight-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-inflight-once = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-inflight-wrappy = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-inflight = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-minimatch-brace-expansion-balanced-match = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-minimatch-brace-expansion-concat-map = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-minimatch-brace-expansion = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-minimatch = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-once = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-parent-is-glob-is-extglob = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-parent-is-glob = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-parent-path-dirname = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-parent = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob-path-is-absolute = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-glob = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-is-negated-glob = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams-readable-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-ordered-read-streams = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-end-of-stream-once = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-end-of-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-readable-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify-stream-shift = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-duplexify = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-pump-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-pump-end-of-stream-once = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-pump-end-of-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-pump-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-pump-once = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify-pump = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-pumpify = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-readable-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-remove-trailing-separator = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob-extend-shallow = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob-is-absolute-is-relative-is-unc-path-unc-path-regex = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob-is-absolute-is-relative-is-unc-path = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob-is-absolute-is-relative = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob-is-absolute-is-windows = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob-is-absolute = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob-is-negated-glob = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-to-absolute-glob = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-json-stable-stringify-jsonify = "PD"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-json-stable-stringify = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-readable-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2-xtend = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-through2 = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter-xtend = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream-through2-filter = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream-unique-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-glob-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-readable-stream = "MIT"
LICENSE_${PN}-mqtt-help-me-through2-xtend = "MIT"
LICENSE_${PN}-mqtt-help-me-through2 = "MIT"
LICENSE_${PN}-mqtt-help-me-xtend = "MIT"
LICENSE_${PN}-mqtt-help-me = "MIT"
LICENSE_${PN}-mqtt-inherits = "ISC"
LICENSE_${PN}-mqtt-minimist = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl-readable-stream = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-bl = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-inherits = "ISC"
LICENSE_${PN}-mqtt-mqtt-packet-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-mqtt-packet = "MIT"
LICENSE_${PN}-mqtt-pump-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-pump-end-of-stream-once = "ISC"
LICENSE_${PN}-mqtt-pump-end-of-stream = "MIT"
LICENSE_${PN}-mqtt-pump-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-pump-once = "ISC"
LICENSE_${PN}-mqtt-pump = "MIT"
LICENSE_${PN}-mqtt-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-readable-stream = "MIT"
LICENSE_${PN}-mqtt-reinterval = "MIT"
LICENSE_${PN}-mqtt-split2-through2-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-split2-through2-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-split2-through2-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-split2-through2-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-split2-through2-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-split2-through2-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-split2-through2-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-split2-through2-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-split2-through2-readable-stream = "MIT"
LICENSE_${PN}-mqtt-split2-through2-xtend = "MIT"
LICENSE_${PN}-mqtt-split2-through2 = "MIT"
LICENSE_${PN}-mqtt-split2 = "ISC"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-end-of-stream-once = "ISC"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-end-of-stream = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-inherits = "ISC"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-readable-stream = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify-stream-shift = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-duplexify = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream-inherits = "ISC"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream-isarray = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream-string-decoder-safe-buffer = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2-readable-stream = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2-xtend = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-through2 = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-ws-options = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-ws-ultron = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-ws = "MIT"
LICENSE_${PN}-mqtt-websocket-stream-xtend = "MIT"
LICENSE_${PN}-mqtt-websocket-stream = "BSD-2-Clause"
LICENSE_${PN}-mqtt-xtend = "MIT"
LICENSE_${PN}-mqtt = "MIT"
LICENSE_${PN}-mustache = "MIT"
LICENSE_${PN}-node-red-node-email-imap-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-node-red-node-email-imap-readable-stream-inherits = "ISC"
LICENSE_${PN}-node-red-node-email-imap-readable-stream-isarray = "MIT"
LICENSE_${PN}-node-red-node-email-imap-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-node-red-node-email-imap-readable-stream = "MIT"
LICENSE_${PN}-node-red-node-email-imap-utf7-semver = "ISC"
LICENSE_${PN}-node-red-node-email-imap-utf7 = "MIT"
LICENSE_${PN}-node-red-node-email-imap = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser-encoding-iconv-lite = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser-encoding = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser-mimelib-addressparser = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser-mimelib-encoding-iconv-lite = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser-mimelib-encoding = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser-mimelib = "EUPL-1.1"
LICENSE_${PN}-node-red-node-email-mailparser-mime = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser-uue-extend = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser-uue = "MIT"
LICENSE_${PN}-node-red-node-email-mailparser = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-libmime-iconv-lite = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-libmime-libbase64 = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-libmime-libqp = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-libmime = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-addressparser = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-libbase64 = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-libmime-iconv-lite = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-libmime-libbase64 = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-libmime-libqp = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-libmime = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-libqp = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-needle-debug-ms = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-needle-debug = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-needle-iconv-lite = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail-needle = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-buildmail = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-libmime-iconv-lite = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-libmime-libbase64 = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-libmime-libqp = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer-libmime = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-mailcomposer = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-needle-debug-ms = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-needle-debug = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-needle-iconv-lite = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-needle = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-nodemailer-direct-transport-smtp-connection = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-nodemailer-direct-transport = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-nodemailer-smtp-transport-clone = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-nodemailer-smtp-transport-nodemailer-wellknown = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-nodemailer-smtp-transport-smtp-connection = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer-nodemailer-smtp-transport = "MIT"
LICENSE_${PN}-node-red-node-email-nodemailer = "MIT"
LICENSE_${PN}-node-red-node-email-poplib-optimist-minimist = "MIT"
LICENSE_${PN}-node-red-node-email-poplib-optimist-wordwrap = "MIT"
LICENSE_${PN}-node-red-node-email-poplib-optimist = "MIT"
LICENSE_${PN}-node-red-node-email-poplib = "MIT"
LICENSE_${PN}-node-red-node-email = "Apache-2.0"
LICENSE_${PN}-node-red-node-feedparser-feedparser-addressparser = "MIT"
LICENSE_${PN}-node-red-node-feedparser-feedparser-array-indexofobject = "MIT"
LICENSE_${PN}-node-red-node-feedparser-feedparser-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-node-red-node-feedparser-feedparser-readable-stream-inherits = "ISC"
LICENSE_${PN}-node-red-node-feedparser-feedparser-readable-stream-isarray = "MIT"
LICENSE_${PN}-node-red-node-feedparser-feedparser-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-node-red-node-feedparser-feedparser-readable-stream = "MIT"
LICENSE_${PN}-node-red-node-feedparser-feedparser-sax = "BSD"
LICENSE_${PN}-node-red-node-feedparser-feedparser = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-aws-sign2 = "Apache-2.0"
LICENSE_${PN}-node-red-node-feedparser-request-aws4 = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-bl-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-bl-readable-stream-inherits = "ISC"
LICENSE_${PN}-node-red-node-feedparser-request-bl-readable-stream-isarray = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-bl-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-bl-readable-stream-string-decoder = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-bl-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-bl-readable-stream = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-bl = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-caseless = "Apache-2.0"
LICENSE_${PN}-node-red-node-feedparser-request-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-combined-stream = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-extend = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-forever-agent = "Apache-2.0"
LICENSE_${PN}-node-red-node-feedparser-request-form-data-async-lodash = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-form-data-async = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-form-data-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-form-data-combined-stream = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-form-data-mime-types-mime-db = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-form-data-mime-types = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-form-data = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-chalk-ansi-styles = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-chalk-escape-string-regexp = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-chalk-has-ansi-ansi-regex = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-chalk-has-ansi = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-chalk-strip-ansi-ansi-regex = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-chalk-strip-ansi = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-chalk-supports-color = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-chalk = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-commander-graceful-readlink = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-commander = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-is-my-json-valid-generate-function = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-is-my-json-valid-generate-object-property-is-property = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-is-my-json-valid-generate-object-property = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-is-my-json-valid-jsonpointer = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-is-my-json-valid-xtend = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-is-my-json-valid = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-pinkie-promise-pinkie = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator-pinkie-promise = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-har-validator = "ISC"
LICENSE_${PN}-node-red-node-feedparser-request-hawk-boom-hoek = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-hawk-boom = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-hawk-cryptiles-boom-hoek = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-hawk-cryptiles-boom = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-hawk-cryptiles = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-hawk-hoek = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-hawk-sntp-hoek = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-hawk-sntp = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-hawk = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-jsprim-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-jsprim-extsprintf = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-jsprim-json-schema = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-jsprim-verror-extsprintf = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-jsprim-verror = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-jsprim = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-asn1 = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-bcrypt-pbkdf-tweetnacl = "PD"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-bcrypt-pbkdf = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-dashdash-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-dashdash = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-ecc-jsbn-jsbn = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-ecc-jsbn = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-getpass-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-getpass = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-jodid25519-jsbn = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-jodid25519 = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-jsbn = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk-tweetnacl = "PD"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature-sshpk = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-http-signature = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-is-typedarray = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-isstream = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-json-stringify-safe = "ISC"
LICENSE_${PN}-node-red-node-feedparser-request-mime-types-mime-db = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-mime-types = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-node-uuid = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-oauth-sign = "Apache-2.0"
LICENSE_${PN}-node-red-node-feedparser-request-qs = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-stringstream = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-tough-cookie-punycode = "MIT"
LICENSE_${PN}-node-red-node-feedparser-request-tough-cookie = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-feedparser-request-tunnel-agent = "Apache-2.0"
LICENSE_${PN}-node-red-node-feedparser-request = "Apache-2.0"
LICENSE_${PN}-node-red-node-feedparser = "Apache-2.0"
LICENSE_${PN}-node-red-node-rbe = "Apache-2.0"
LICENSE_${PN}-node-red-node-twitter-oauth = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-aws-sign2 = "Apache-2.0"
LICENSE_${PN}-node-red-node-twitter-request-aws4 = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-caseless = "Apache-2.0"
LICENSE_${PN}-node-red-node-twitter-request-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-combined-stream = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-extend = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-forever-agent = "Apache-2.0"
LICENSE_${PN}-node-red-node-twitter-request-form-data-asynckit = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-form-data-combined-stream-delayed-stream = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-form-data-combined-stream = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-form-data-mime-types-mime-db = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-form-data-mime-types = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-form-data = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-har-validator-ajv-co = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-har-validator-ajv-json-stable-stringify-jsonify = "PD"
LICENSE_${PN}-node-red-node-twitter-request-har-validator-ajv-json-stable-stringify = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-har-validator-ajv = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-har-validator-har-schema = "ISC"
LICENSE_${PN}-node-red-node-twitter-request-har-validator = "ISC"
LICENSE_${PN}-node-red-node-twitter-request-hawk-boom-hoek = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-hawk-boom = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-hawk-cryptiles-boom-hoek = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-hawk-cryptiles-boom = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-hawk-cryptiles = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-hawk-hoek = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-hawk-sntp-hoek = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-hawk-sntp = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-hawk = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-jsprim-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-jsprim-extsprintf = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-jsprim-json-schema = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-jsprim-verror-extsprintf = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-jsprim-verror = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-jsprim = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-asn1 = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-bcrypt-pbkdf-tweetnacl = "PD"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-bcrypt-pbkdf = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-dashdash-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-dashdash = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-ecc-jsbn-jsbn = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-ecc-jsbn = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-getpass-assert-plus = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-getpass = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-jodid25519-jsbn = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-jodid25519 = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-jsbn = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk-tweetnacl = "PD"
LICENSE_${PN}-node-red-node-twitter-request-http-signature-sshpk = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-http-signature = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-is-typedarray = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-isstream = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-json-stringify-safe = "ISC"
LICENSE_${PN}-node-red-node-twitter-request-mime-types-mime-db = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-mime-types = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-oauth-sign = "Apache-2.0"
LICENSE_${PN}-node-red-node-twitter-request-performance-now = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-qs = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-safe-buffer = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-stringstream = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-tough-cookie-punycode = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-tough-cookie = "BSD-3-Clause"
LICENSE_${PN}-node-red-node-twitter-request-tunnel-agent-safe-buffer = "MIT"
LICENSE_${PN}-node-red-node-twitter-request-tunnel-agent = "Apache-2.0"
LICENSE_${PN}-node-red-node-twitter-request-uuid = "MIT"
LICENSE_${PN}-node-red-node-twitter-request = "Apache-2.0"
LICENSE_${PN}-node-red-node-twitter-twitter-ng-oauth = "MIT"
LICENSE_${PN}-node-red-node-twitter-twitter-ng = "MIT"
LICENSE_${PN}-node-red-node-twitter = "Apache-2.0"
LICENSE_${PN}-nopt-abbrev = "ISC"
LICENSE_${PN}-nopt = "ISC"
LICENSE_${PN}-oauth2orize-debug-ms = "MIT"
LICENSE_${PN}-oauth2orize-debug = "MIT"
LICENSE_${PN}-oauth2orize-uid2 = "MIT"
LICENSE_${PN}-oauth2orize-utils-merge = "MIT"
LICENSE_${PN}-oauth2orize = "MIT"
LICENSE_${PN}-on-headers = "MIT"
LICENSE_${PN}-passport-http-bearer-passport-strategy = "MIT"
LICENSE_${PN}-passport-http-bearer = "MIT"
LICENSE_${PN}-passport-oauth2-client-password-passport-strategy = "MIT"
LICENSE_${PN}-passport-oauth2-client-password = "MIT"
LICENSE_${PN}-passport-passport-strategy = "MIT"
LICENSE_${PN}-passport-pause = "MIT"
LICENSE_${PN}-passport = "MIT"
LICENSE_${PN}-raw-body-bytes = "MIT"
LICENSE_${PN}-raw-body-iconv-lite = "MIT"
LICENSE_${PN}-raw-body-unpipe = "MIT"
LICENSE_${PN}-raw-body = "MIT"
LICENSE_${PN}-semver = "ISC"
LICENSE_${PN}-sentiment = "MIT"
LICENSE_${PN}-uglify-js-async = "MIT"
LICENSE_${PN}-uglify-js-source-map = "BSD-3-Clause"
LICENSE_${PN}-uglify-js-uglify-to-browserify = "MIT"
LICENSE_${PN}-uglify-js-yargs-camelcase = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-center-align-align-text-kind-of-is-buffer = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-center-align-align-text-kind-of = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-center-align-align-text-longest = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-center-align-align-text-repeat-string = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-center-align-align-text = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-center-align-lazy-cache = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-center-align = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-right-align-align-text-kind-of-is-buffer = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-right-align-align-text-kind-of = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-right-align-align-text-longest = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-right-align-align-text-repeat-string = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-right-align-align-text = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-right-align = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui-wordwrap = "MIT"
LICENSE_${PN}-uglify-js-yargs-cliui = "ISC"
LICENSE_${PN}-uglify-js-yargs-decamelize = "MIT"
LICENSE_${PN}-uglify-js-yargs-window-size = "MIT"
LICENSE_${PN}-uglify-js-yargs = "MIT"
LICENSE_${PN}-uglify-js = "BSD-2-Clause"
LICENSE_${PN}-when = "MIT"
LICENSE_${PN}-ws-options = "MIT"
LICENSE_${PN}-ws-ultron = "MIT"
LICENSE_${PN}-ws = "MIT"
LICENSE_${PN}-xml2js-sax = "ISC"
LICENSE_${PN}-xml2js-xmlbuilder-lodash = "MIT"
LICENSE_${PN}-xml2js-xmlbuilder = "MIT"
LICENSE_${PN}-xml2js = "MIT"
LICENSE_${PN} = "Apache-2.0"

RDEPENDS_${PN} += "python"

DEPENDS += "bash"
RDEPENDS_${PN}-node-red-node-feedparser-request-node-uuid += "bash"
