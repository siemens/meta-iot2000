# Dummy recipe in case meta-golang is not used
LICENSE=""
