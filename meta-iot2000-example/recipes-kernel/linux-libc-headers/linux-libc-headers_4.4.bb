require recipes-kernel/linux-libc-headers/linux-libc-headers.inc
require recipes-kernel/linux/linux-cip_4.4.inc
