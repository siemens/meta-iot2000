SRC_URI_remove = "http://people.seas.harvard.edu/~apw/${BPN}/${BP}.tar.gz"
SRC_URI += "http://deb.debian.org/debian/pool/main/s/stress/${BPN}_${PV}.orig.tar.gz"
