FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

INITSCRIPT_PARAMS_${PN} = "defaults"
