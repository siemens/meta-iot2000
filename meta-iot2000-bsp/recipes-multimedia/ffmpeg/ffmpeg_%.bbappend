def cpu(d):
    return "i586"
