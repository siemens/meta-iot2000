require iot2000-example-image-rt.bb
require example-image-swu.inc
