# Dummy recipe in case meta-mingw is not used
LICENSE=""
