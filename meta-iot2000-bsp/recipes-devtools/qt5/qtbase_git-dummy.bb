# Dummy recipe in case meta-qt5 is not used
LICENSE=""
