# Dummy recipe in case nodejs 8 is not available
LICENSE=""
