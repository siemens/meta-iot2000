FILESEXTRAPATHS_prepend := "${THISDIR}/patches-1.8:"

require go-cross-iot2000.inc
