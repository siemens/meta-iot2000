require recipes-kernel/linux/linux-cip_4.4.inc
