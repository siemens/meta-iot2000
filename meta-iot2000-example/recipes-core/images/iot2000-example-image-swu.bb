require iot2000-example-image.bb
require example-image-swu.inc
