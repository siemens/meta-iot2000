FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-make-bnrand_range-reliable-with-deterministic-run-ti.patch"
