require core-image-minimal.bb
require core-image-iot2000.inc
