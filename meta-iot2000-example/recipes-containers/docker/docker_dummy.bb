# Dummy recipe in case meta-virtualization is not used
LICENSE=""
