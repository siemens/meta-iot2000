# suppress automatic service activation
updatercd_postinst() {
}
