# workaround for dependency issues in upstream mingw build
PARALLEL_MAKE = ""
