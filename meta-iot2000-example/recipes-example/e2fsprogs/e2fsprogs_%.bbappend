#This recipe adds "resize2fs" as dependencie so it will be installed with the 
#default package

RDEPENDS_e2fsprogs += " e2fsprogs-resize2fs"
