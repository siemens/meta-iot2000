EXTRA_OEMAKE += "NO_UUID=1"
