SUMMARY = "A set of dashboard nodes for Node-RED"

# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
LICENSE = "Apache-2.0 & MIT & ISC"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f289d543031cf6f8f1943a54d087eeac"

inherit npm-ng

NPM_LOCAL_INSTALL_DIR = "/home/root/.node-red"
