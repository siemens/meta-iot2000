# Dummy recipe in case stress is not available
LICENSE=""
